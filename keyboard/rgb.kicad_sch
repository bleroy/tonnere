File: keyboard/rgb.kicad_sch (KiCad schematic)
At the start: 2 parts

Commit message: ISO version of the keyboard
Parts:
- renumbered C75 to C67, D149 to D133
